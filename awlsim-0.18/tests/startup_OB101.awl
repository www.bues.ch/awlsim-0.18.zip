ORGANIZATION_BLOCK OB 101
BEGIN
	L		MD 0
	__ASSERT==	__ACCU 1,	0
	L		101
	T		MD 0
END_ORGANIZATION_BLOCK



ORGANIZATION_BLOCK OB 1
BEGIN
	L		MD 0
	__ASSERT==	__ACCU 1,	101
END_ORGANIZATION_BLOCK
