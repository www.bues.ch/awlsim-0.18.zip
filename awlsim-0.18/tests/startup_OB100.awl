ORGANIZATION_BLOCK OB 100
BEGIN
	L		MD 0
	__ASSERT==	__ACCU 1,	0
	L		100
	T		MD 0
END_ORGANIZATION_BLOCK



ORGANIZATION_BLOCK OB 1
BEGIN
	L		MD 0
	__ASSERT==	__ACCU 1,	100
END_ORGANIZATION_BLOCK
