ORGANIZATION_BLOCK OB 102
BEGIN
	L		MD 0
	__ASSERT==	__ACCU 1,	0
	L		102
	T		MD 0
END_ORGANIZATION_BLOCK



ORGANIZATION_BLOCK OB 1
BEGIN
	L		MD 0
	__ASSERT==	__ACCU 1,	102
END_ORGANIZATION_BLOCK
